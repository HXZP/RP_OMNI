# Keil uVision project rp_first.uvprojx, settings and files
target rp_first (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: rp_first +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,ARM_MATH_CM4,ARM_MATH_LOOPUNROLL
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USER;../USER/RP_DEVICES;../USER/RP_DEVICES/RM_MOTOR;../USER/RP_DEVICES/RP_IMU;../USER/RP_DEVICES/RP_IMU/bmi270;../USER/RP_DRIVERS;../USER/TASKS;../USER/RP_CONFI;../USER/RP_DEVICES/RM_JUDGE_VISION;../USER/POTOCAL_PORT;../USER/DSP;../USER/CMSIS/DSP/Include/dsp;../Drivers/CMSIS/DSP/Include;../Drivers/STM32F4xx_HAL_Driver;../USER/RP_FUNCTION;../USER/RP_MODULES
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group USER/DSP
    ../USER/DSP/: arm_atan2_f32.c arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_mat_init_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_math.h arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c arm_divide_q15.c arm_divide_q31.c arm_vexp_f16.c arm_vexp_f32.c arm_vexp_f64.c arm_vinverse_f16.c arm_vlog_f16.c arm_vlog_f32.c arm_vlog_f64.c arm_vlog_q15.c arm_vlog_q31.c arm_atan2_f16.c arm_atan2_q15.c arm_atan2_q31.c arm_common_tables.c arm_common_tables_f16.c arm_const_structs.c arm_const_structs_f16.c arm_mve_tables.c arm_mve_tables_f16.c CMakeLists.txt arm_abs_f16.c arm_abs_f32.c arm_abs_f64.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f16.c arm_add_f32.c arm_add_f64.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_and_u8.c arm_and_u16.c arm_and_u32.c arm_clip_f16.c arm_clip_f32.c arm_clip_q7.c arm_clip_q15.c arm_clip_q31.c arm_dot_prod_f16.c arm_dot_prod_f32.c arm_dot_prod_f64.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f16.c arm_mult_f32.c arm_mult_f64.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f16.c arm_negate_f32.c arm_negate_f64.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_not_u8.c arm_not_u16.c arm_not_u32.c arm_offset_f16.c arm_offset_f32.c arm_offset_f64.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_or_u8.c arm_or_u16.c arm_or_u32.c arm_scale_f16.c arm_scale_f32.c arm_scale_f64.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f16.c arm_sub_f32.c arm_sub_f64.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c arm_xor_u8.c arm_xor_u16.c arm_xor_u32.c
  group USER/CONFI
    ../USER/RP_CONFI/: THE_BEST_BLESS_FOR_RPers.h RP_CONFIG.h RP_INIT.c
    ../USER/: log.txt
  group USER/FUNCTION
    ../USER/RP_FUNCTION/: RP_FUNCTION.h GimbalRotationOutput.c RP_MATH.c
  group USER/TASKS
    ../USER/TASKS/: Tasks_Center.c
  group USER/MODULES
    ../USER/RP_MODULES/: center.c auto.c rifle.c gimbal.c chassis.c
  group USER/POTOCAL_PORT
    ../USER/POTOCAL_PORT/: can_potocal.c usart_potocal.c
  group USER/DRIVERS
    ../USER/RP_DRIVERS/: DRIVERS.h type.h tick_drv.c gpio_drv.c iic_drv.c spi_drv.c can_drv.c uart_drv.c
  group USER/DEVICES
    ../USER/RP_DEVICES/: DEVICES.h rc.c led.c cap.c imu.c servo.c motor.c master.c
  group USER/DEVICES/JUDGE_VISION
    ../USER/RP_DEVICES/RM_JUDGE_VISION/: crc.c judge.c vision.c
  group USER/DEVICES/RM_MOTOR
    ../USER/RP_DEVICES/RM_MOTOR/: rm_motor.c rm_motor.h rm_motor_def.h
  group USER/DEVICES/RP_IMU/bmi270
    ../USER/RP_DEVICES/RP_IMU/bmi270/: BMI.c bmi2.c bmi270.c common.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
